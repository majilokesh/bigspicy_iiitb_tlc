** SPICE netlist generated by bigspicy.py at Fri Dec  9 13:41:20 2022 UTC
.SUBCKT iiitb_tlc
+ C VGND VPWR clk rst_n light_farm.0 light_farm.1 light_farm.2 light_highway.0 light_highway.1 light_highway.2
** replacing FILLER_0_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_20 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_0_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_29/VPB =>[signal: VPWR w=1]]']]
FILLER_0_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_41/VPB =>[signal: VPWR w=1]]']]
FILLER_0_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_57 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_63 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_63/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_63/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_63/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_63/VPB =>[signal: VPWR w=1]]']]
FILLER_0_63 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_75 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_0_8 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_8/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_8/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_8/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_8/VPB =>[signal: VPWR w=1]]']]
FILLER_0_8 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_0_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_85/VPB =>[signal: VPWR w=1]]']]
FILLER_0_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_10_101 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_101_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_101_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_107 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_15/VPB =>[signal: VPWR w=1]]']]
FILLER_10_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_29/VPB =>[signal: VPWR w=1]]']]
FILLER_10_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_3/VPB =>[signal: VPWR w=1]]']]
FILLER_10_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_41 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_65/VPB =>[signal: VPWR w=1]]']]
FILLER_10_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_10_85 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_10_93 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_11_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_11_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_15/VPB =>[signal: VPWR w=1]]']]
FILLER_11_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_27/VPB =>[signal: VPWR w=1]]']]
FILLER_11_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_3/VPB =>[signal: VPWR w=1]]']]
FILLER_11_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_39/VPB =>[signal: VPWR w=1]]']]
FILLER_11_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_11_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_11_57 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_11_62 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_62/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_62/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_62/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_62/VPB =>[signal: VPWR w=1]]']]
FILLER_11_62 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_74 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_74_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_74_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_11_82 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_82_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_82_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_12_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_12_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_15/VPB =>[signal: VPWR w=1]]']]
FILLER_12_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_29/VPB =>[signal: VPWR w=1]]']]
FILLER_12_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_3/VPB =>[signal: VPWR w=1]]']]
FILLER_12_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_47 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_51 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_51/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_51/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_51/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_51/VPB =>[signal: VPWR w=1]]']]
FILLER_12_51 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_63 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_63/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_63/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_63/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_63/VPB =>[signal: VPWR w=1]]']]
FILLER_12_63 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_75 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_12_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_85/VPB =>[signal: VPWR w=1]]']]
FILLER_12_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_13_106 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_13_15 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_13_23 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_3/VPB =>[signal: VPWR w=1]]']]
FILLER_13_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_30 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_30/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_30/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_30/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_30/VPB =>[signal: VPWR w=1]]']]
FILLER_13_30 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_42 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_42/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_42/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_42/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_42/VPB =>[signal: VPWR w=1]]']]
FILLER_13_42 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_54 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_13_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_57/VPB =>[signal: VPWR w=1]]']]
FILLER_13_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_13_73 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_94 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_94/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_94/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_94/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_94/VPB =>[signal: VPWR w=1]]']]
FILLER_13_94 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_14_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_15/VPB =>[signal: VPWR w=1]]']]
FILLER_14_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_14_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_29/VPB =>[signal: VPWR w=1]]']]
FILLER_14_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_3/VPB =>[signal: VPWR w=1]]']]
FILLER_14_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_41/VPB =>[signal: VPWR w=1]]']]
FILLER_14_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_53/VPB =>[signal: VPWR w=1]]']]
FILLER_14_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_65/VPB =>[signal: VPWR w=1]]']]
FILLER_14_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_14_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_14_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_85/VPB =>[signal: VPWR w=1]]']]
FILLER_14_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_15_20 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_15_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_3/VPB =>[signal: VPWR w=1]]']]
FILLER_15_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_45 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_15_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_57/VPB =>[signal: VPWR w=1]]']]
FILLER_15_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_69/VPB =>[signal: VPWR w=1]]']]
FILLER_15_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_81/VPB =>[signal: VPWR w=1]]']]
FILLER_15_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_93/VPB =>[signal: VPWR w=1]]']]
FILLER_15_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_16_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_16_22 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_16_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_29/VPB =>[signal: VPWR w=1]]']]
FILLER_16_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_3/VPB =>[signal: VPWR w=1]]']]
FILLER_16_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_41/VPB =>[signal: VPWR w=1]]']]
FILLER_16_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_53/VPB =>[signal: VPWR w=1]]']]
FILLER_16_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_65/VPB =>[signal: VPWR w=1]]']]
FILLER_16_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_16_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_16_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_85/VPB =>[signal: VPWR w=1]]']]
FILLER_16_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_17_106 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_17_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_17_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_17_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_17_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_17_35 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_35/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_35/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_35/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_35/VPB =>[signal: VPWR w=1]]']]
FILLER_17_35 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_47 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_17_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_57/VPB =>[signal: VPWR w=1]]']]
FILLER_17_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_69/VPB =>[signal: VPWR w=1]]']]
FILLER_17_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_17_85 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_17_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_9/VPB =>[signal: VPWR w=1]]']]
FILLER_17_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_93 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_17_98 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_98_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_98_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_1_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_15/VPB =>[signal: VPWR w=1]]']]
FILLER_1_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_27/VPB =>[signal: VPWR w=1]]']]
FILLER_1_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_3/VPB =>[signal: VPWR w=1]]']]
FILLER_1_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_39/VPB =>[signal: VPWR w=1]]']]
FILLER_1_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_57/VPB =>[signal: VPWR w=1]]']]
FILLER_1_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_69/VPB =>[signal: VPWR w=1]]']]
FILLER_1_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_81/VPB =>[signal: VPWR w=1]]']]
FILLER_1_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_93/VPB =>[signal: VPWR w=1]]']]
FILLER_1_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_2_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_15/VPB =>[signal: VPWR w=1]]']]
FILLER_2_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_29/VPB =>[signal: VPWR w=1]]']]
FILLER_2_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_3/VPB =>[signal: VPWR w=1]]']]
FILLER_2_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_47 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_56 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_56/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_56/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_56/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_56/VPB =>[signal: VPWR w=1]]']]
FILLER_2_56 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_68 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_68/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_68/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_68/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_68/VPB =>[signal: VPWR w=1]]']]
FILLER_2_68 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_2_90 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_90_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_90_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_3_100 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_100_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_100_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_3_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_15/VPB =>[signal: VPWR w=1]]']]
FILLER_3_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_27/VPB =>[signal: VPWR w=1]]']]
FILLER_3_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_3/VPB =>[signal: VPWR w=1]]']]
FILLER_3_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_39/VPB =>[signal: VPWR w=1]]']]
FILLER_3_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_3_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_57/VPB =>[signal: VPWR w=1]]']]
FILLER_3_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_3_76 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_76/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_76/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_76/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_76/VPB =>[signal: VPWR w=1]]']]
FILLER_3_76 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_88 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_88/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_88/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_88/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_88/VPB =>[signal: VPWR w=1]]']]
FILLER_3_88 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_4_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_15/VPB =>[signal: VPWR w=1]]']]
FILLER_4_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_4_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_29/VPB =>[signal: VPWR w=1]]']]
FILLER_4_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_3/VPB =>[signal: VPWR w=1]]']]
FILLER_4_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_41/VPB =>[signal: VPWR w=1]]']]
FILLER_4_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_53/VPB =>[signal: VPWR w=1]]']]
FILLER_4_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_65 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_69 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_76 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_76_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_76_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_4_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_85/VPB =>[signal: VPWR w=1]]']]
FILLER_4_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_5_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_5_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_15/VPB =>[signal: VPWR w=1]]']]
FILLER_5_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_27/VPB =>[signal: VPWR w=1]]']]
FILLER_5_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_3/VPB =>[signal: VPWR w=1]]']]
FILLER_5_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_39/VPB =>[signal: VPWR w=1]]']]
FILLER_5_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_57/VPB =>[signal: VPWR w=1]]']]
FILLER_5_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_69/VPB =>[signal: VPWR w=1]]']]
FILLER_5_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_81/VPB =>[signal: VPWR w=1]]']]
FILLER_5_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_93/VPB =>[signal: VPWR w=1]]']]
FILLER_5_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_106 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_6_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_15/VPB =>[signal: VPWR w=1]]']]
FILLER_6_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_29/VPB =>[signal: VPWR w=1]]']]
FILLER_6_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_3/VPB =>[signal: VPWR w=1]]']]
FILLER_6_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_41/VPB =>[signal: VPWR w=1]]']]
FILLER_6_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_53/VPB =>[signal: VPWR w=1]]']]
FILLER_6_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_65/VPB =>[signal: VPWR w=1]]']]
FILLER_6_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_6_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_85/VPB =>[signal: VPWR w=1]]']]
FILLER_6_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_7_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_15/VPB =>[signal: VPWR w=1]]']]
FILLER_7_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_27/VPB =>[signal: VPWR w=1]]']]
FILLER_7_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_3/VPB =>[signal: VPWR w=1]]']]
FILLER_7_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_39/VPB =>[signal: VPWR w=1]]']]
FILLER_7_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_57/VPB =>[signal: VPWR w=1]]']]
FILLER_7_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_69/VPB =>[signal: VPWR w=1]]']]
FILLER_7_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_81/VPB =>[signal: VPWR w=1]]']]
FILLER_7_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_93/VPB =>[signal: VPWR w=1]]']]
FILLER_7_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_8_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_15/VPB =>[signal: VPWR w=1]]']]
FILLER_8_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_29/VPB =>[signal: VPWR w=1]]']]
FILLER_8_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_3/VPB =>[signal: VPWR w=1]]']]
FILLER_8_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_41/VPB =>[signal: VPWR w=1]]']]
FILLER_8_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_53/VPB =>[signal: VPWR w=1]]']]
FILLER_8_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_65/VPB =>[signal: VPWR w=1]]']]
FILLER_8_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_8_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_85/VPB =>[signal: VPWR w=1]]']]
FILLER_8_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_9_105 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_9_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_15/VPB =>[signal: VPWR w=1]]']]
FILLER_9_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_27 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_9_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_3/VPB =>[signal: VPWR w=1]]']]
FILLER_9_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_35 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_9_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_39/VPB =>[signal: VPWR w=1]]']]
FILLER_9_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_9_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_57/VPB =>[signal: VPWR w=1]]']]
FILLER_9_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_9_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_93/VPB =>[signal: VPWR w=1]]']]
FILLER_9_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_28 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_28_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_28_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_29 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_30 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_31 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_31_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_31_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_32 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_32_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_32_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_33 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_34 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_35 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_36 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_37 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_38 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_39 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_40 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_41 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_42 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_43 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_44 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_45 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_46 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_47 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_48 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_49 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_50 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_51 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_52 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_53 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_54 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_55 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_56 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_57 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_58 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_59 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_60 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_61 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_62 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_63 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_64 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_65 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _05_ with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__05__0 _05__a_27_47# state[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__05__1 _05__a_27_47# state[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__05__2 _00_ _05__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__05__3 VPWR _05__a_27_47# _00_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__05__4 _00_ _05__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__05__5 VGND _05__a_27_47# _00_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _06_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__06__0 _06__a_109_297# state[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__06__1 net5 state[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__06__2 VGND _00_ net5 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__06__3 net5 _00_ _06__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _07_ with the contents of sky130_fd_sc_hd__and2b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_207_413# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__07__0 _07__a_207_413# _00_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_207_413# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__07__1 VPWR _07__a_207_413# _01_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_207_413# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__07__2 VGND _07__a_207_413# _01_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_207_413# w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_297_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__07__3 _07__a_207_413# _07__a_27_413# _07__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__07__4 _07__a_27_413# state[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_27_413# w=1]]', 's: [connection X5/s =>[signal: a_207_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__07__5 VPWR _07__a_27_413# _07__a_207_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A_N w=1]]', 's: [connection X6/s =>[signal: a_27_413# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__07__6 VGND state[0] _07__a_27_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_297_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__07__7 _07__a_297_47# _00_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _08_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__08__0 VGND _01_ _08__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__08__1 net3 _08__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__08__2 net3 _08__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__08__3 VPWR _01_ _08__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _09_ with the contents of sky130_fd_sc_hd__o21ba_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_448_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__09__0 _09__a_448_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B1_N w=1]]', 's: [connection X1/s =>[signal: a_222_93# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__09__1 VPWR state[0] _09__a_222_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_199# w=1]]', 'g: [connection X2/g =>[signal: a_222_93# w=1]]', 's: [connection X2/s =>[signal: a_448_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__09__2 _09__a_79_199# _09__a_222_93# _09__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1_N w=1]]', 's: [connection X3/s =>[signal: a_222_93# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__09__3 VGND state[0] _09__a_222_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_448_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__09__4 VGND _00_ _09__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_544_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__09__5 _09__a_544_297# _00_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_79_199# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__09__6 next_state[0] _09__a_79_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_199# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__09__7 next_state[0] _09__a_79_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VPWR w=1]]', 'g: [connection X8/g =>[signal: a_222_93# w=1]]', 's: [connection X8/s =>[signal: a_79_199# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__09__8 VPWR _09__a_222_93# _09__a_79_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_79_199# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: a_544_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__09__9 _09__a_79_199# net1 _09__a_544_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _10_ with the contents of sky130_fd_sc_hd__xor2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_35_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__10__0 _10__a_35_297# state[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_35_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__10__1 VGND _00_ _10__a_35_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_35_297# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__10__2 next_state[1] _10__a_35_297# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_285_297# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__10__3 _10__a_285_297# _00_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: a_285_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__10__4 VPWR state[0] _10__a_285_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_35_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_117_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__10__5 _10__a_35_297# _00_ _10__a_117_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_117_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__10__6 _10__a_117_297# state[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_285_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__10__7 _10__a_285_47# _00_ next_state[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_285_297# w=1]]', 'g: [connection X8/g =>[signal: a_35_297# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__10__8 _10__a_285_297# _10__a_35_297# next_state[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_285_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__10__9 VGND state[0] _10__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _11_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__11__0 VGND _11__a_59_75# _02_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__11__1 VPWR state[0] _11__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__11__2 _11__a_59_75# state[0] _11__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__11__3 _11__a_59_75# _00_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__11__4 _11__a_145_75# _00_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__11__5 VPWR _11__a_59_75# _02_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _12_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__12__0 VGND _02_ _12__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__12__1 net4 _12__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__12__2 net4 _12__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__12__3 VPWR _02_ _12__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _14_ with the contents of sky130_fd_sc_hd__and2b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_207_413# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__14__0 _14__a_207_413# state[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_207_413# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__14__1 VPWR _14__a_207_413# _03_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_207_413# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__14__2 VGND _14__a_207_413# _03_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_207_413# w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_297_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__14__3 _14__a_207_413# _14__a_27_413# _14__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__14__4 _14__a_27_413# _00_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_27_413# w=1]]', 's: [connection X5/s =>[signal: a_207_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__14__5 VPWR _14__a_27_413# _14__a_207_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A_N w=1]]', 's: [connection X6/s =>[signal: a_27_413# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__14__6 VGND _00_ _14__a_27_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_297_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__14__7 _14__a_297_47# state[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _15_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__15__0 VGND _03_ _15__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__15__1 net6 _15__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__15__2 net6 _15__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__15__3 VPWR _03_ _15__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _16_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__16__0 VGND _00_ _16__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__16__1 _04_ _16__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__16__2 _04_ _16__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__16__3 VPWR _00_ _16__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _17_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__17__0 VGND _04_ _17__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__17__1 net7 _17__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__17__2 net7 _17__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__17__3 VPWR _04_ _17__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _18_ with the contents of sky130_fd_sc_hd__dfrtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__18__0 _18__a_1270_413# _18__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Q w=1]]', 'g: [connection X1/g =>[signal: a_1283_21# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__18__1 state[0] _18__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__18__2 VPWR _18__a_543_47# _18__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_543_47# w=1]]', 's: [connection X3/s =>[signal: a_761_289# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__18__3 VGND _18__a_543_47# _18__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: D w=1]]', 's: [connection X4/s =>[signal: a_448_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__18__4 VGND next_state[0] _18__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1108_47# w=1]]', 'g: [connection X5/g =>[signal: a_193_47# w=1]]', 's: [connection X5/s =>[signal: a_1270_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__18__5 _18__a_1108_47# _18__a_193_47# _18__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: Q w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__18__6 VGND _18__a_1283_21# state[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_1217_47# w=1]]', 'g: [connection X7/g =>[signal: a_1283_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__18__7 _18__a_1217_47# _18__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__18__8 _18__a_448_47# _18__a_27_47# _18__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_448_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_543_47# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__18__9 _18__a_448_47# _18__a_193_47# _18__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_543_47# w=1]]', 'g: [connection X10/g =>[signal: a_193_47# w=1]]', 's: [connection X10/s =>[signal: a_639_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__18__10 _18__a_543_47# _18__a_193_47# _18__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1108_47# w=1]]', 'g: [connection X11/g =>[signal: a_27_47# w=1]]', 's: [connection X11/s =>[signal: a_1217_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__18__11 _18__a_1108_47# _18__a_27_47# _18__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_1462_47# w=1]]', 'g: [connection X12/g =>[signal: a_1108_47# w=1]]', 's: [connection X12/s =>[signal: a_1283_21# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__18__12 _18__a_1462_47# _18__a_1108_47# _18__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_543_47# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_651_413# w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__18__13 _18__a_543_47# _18__a_27_47# _18__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_805_47# w=1]]', 'g: [connection X14/g =>[signal: RESET_B w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__18__14 _18__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Q w=1]]', 'g: [connection X15/g =>[signal: a_1283_21# w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__18__15 state[0] _18__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_761_289# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_1108_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__18__16 _18__a_761_289# _18__a_193_47# _18__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VPWR w=1]]', 'g: [connection X17/g =>[signal: RESET_B w=1]]', 's: [connection X17/s =>[signal: a_651_413# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__18__17 VPWR net2 _18__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_193_47# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__18__18 VGND _18__a_27_47# _18__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__18__19 _18__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__18__20 _18__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VPWR w=1]]', 'g: [connection X21/g =>[signal: a_1283_21# w=1]]', 's: [connection X21/s =>[signal: Q w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__18__21 VPWR _18__a_1283_21# state[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__18__22 VPWR _18__a_27_47# _18__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_1283_21# w=1]]', 'g: [connection X23/g =>[signal: a_1108_47# w=1]]', 's: [connection X23/s =>[signal: VPWR w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__18__23 _18__a_1283_21# _18__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VGND w=1]]', 'g: [connection X24/g =>[signal: RESET_B w=1]]', 's: [connection X24/s =>[signal: a_1462_47# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__18__24 VGND net2 _18__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VPWR w=1]]', 'g: [connection X25/g =>[signal: D w=1]]', 's: [connection X25/s =>[signal: a_448_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__18__25 VPWR next_state[0] _18__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: a_651_413# w=1]]', 'g: [connection X26/g =>[signal: a_761_289# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__18__26 _18__a_651_413# _18__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_761_289# w=1]]', 'g: [connection X27/g =>[signal: a_27_47# w=1]]', 's: [connection X27/s =>[signal: a_1108_47# w=1]]', 'b: [connection X27/b =>[signal: VPB w=1]]']]
X__18__27 _18__a_761_289# _18__a_27_47# _18__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: RESET_B w=1]]', 's: [connection X28/s =>[signal: a_1283_21# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__18__28 VPWR net2 _18__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: a_639_47# w=1]]', 'g: [connection X29/g =>[signal: a_761_289# w=1]]', 's: [connection X29/s =>[signal: a_805_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__18__29 _18__a_639_47# _18__a_761_289# _18__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _19_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__19__0 _19__a_1270_413# _19__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__19__1 VPWR _19__a_543_47# _19__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__19__2 VGND _19__a_543_47# _19__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__19__3 VGND next_state[1] _19__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__19__4 _19__a_1108_47# _19__a_193_47# _19__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__19__5 VGND _19__a_1283_21# state[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__19__6 _19__a_1217_47# _19__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__19__7 _19__a_448_47# _19__a_27_47# _19__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__19__8 _19__a_448_47# _19__a_193_47# _19__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__19__9 _19__a_543_47# _19__a_193_47# _19__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__19__10 _19__a_1108_47# _19__a_27_47# _19__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__19__11 _19__a_1462_47# _19__a_1108_47# _19__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__19__12 _19__a_543_47# _19__a_27_47# _19__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__19__13 _19__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__19__14 _19__a_761_289# _19__a_193_47# _19__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__19__15 VPWR net2 _19__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__19__16 VGND _19__a_27_47# _19__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__19__17 _19__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__19__18 _19__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__19__19 VPWR _19__a_1283_21# state[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__19__20 VPWR _19__a_27_47# _19__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__19__21 _19__a_1283_21# _19__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__19__22 VGND net2 _19__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__19__23 VPWR next_state[1] _19__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__19__24 _19__a_651_413# _19__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__19__25 _19__a_761_289# _19__a_27_47# _19__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__19__26 VPWR net2 _19__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__19__27 _19__a_639_47# _19__a_761_289# _19__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_0_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_0 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_1 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_2 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_3 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_4 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_5 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_6 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_7 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_8 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_9 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_10 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_11 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_12 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_13 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_14 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_15 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_16 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_17 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_18 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_19 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_20 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_21 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_22 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_23 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_24 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_25 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_26 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_27 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_28 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_29 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_30 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_31 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_32 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_33 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_34 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_35 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_36 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_37 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_38 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_39 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_0__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_0 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_1 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_2 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_3 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_4 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_5 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_6 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_7 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_8 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_9 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_10 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_11 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_12 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_13 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_14 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_15 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_16 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_17 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_18 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_19 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_20 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_21 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_22 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_23 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_24 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_25 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_26 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_27 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_28 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_29 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_30 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_31 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_32 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_33 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_34 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_35 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_36 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_37 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_38 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_39 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_1__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_0 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_1 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_2 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_3 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_4 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_5 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_6 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_7 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_8 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_9 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_10 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_11 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_12 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_13 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_14 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_15 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_16 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_17 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_18 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_19 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_20 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_21 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_22 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_23 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_24 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_25 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_26 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_27 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_28 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_29 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_30 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_31 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_32 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_33 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_34 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_35 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_36 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_37 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_38 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_39 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 VGND C input1_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input1_1 net1 input1_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 net1 input1_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 VPWR C input1_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 VGND rst_n input2_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 net2 input2_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 net2 input2_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR rst_n input2_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing output3 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output3_0 light_farm.0 output3_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output3_1 output3_a_27_47# net3 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output3_2 VGND output3_a_27_47# light_farm.0 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output3_3 light_farm.0 output3_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output3_4 VPWR output3_a_27_47# light_farm.0 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output3_5 output3_a_27_47# net3 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output4 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output4_0 light_farm.1 output4_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output4_1 output4_a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output4_2 VGND output4_a_27_47# light_farm.1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output4_3 light_farm.1 output4_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output4_4 VPWR output4_a_27_47# light_farm.1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output4_5 output4_a_27_47# net4 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output5 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output5_0 light_highway.0 output5_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output5_1 output5_a_27_47# net5 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output5_2 VGND output5_a_27_47# light_highway.0 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output5_3 light_highway.0 output5_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output5_4 VPWR output5_a_27_47# light_highway.0 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output5_5 output5_a_27_47# net5 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output6 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output6_0 light_highway.1 output6_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output6_1 output6_a_27_47# net6 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output6_2 VGND output6_a_27_47# light_highway.1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output6_3 light_highway.1 output6_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output6_4 VPWR output6_a_27_47# light_highway.1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output6_5 output6_a_27_47# net6 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output7 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output7_0 light_highway.2 output7_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output7_1 output7_a_27_47# net7 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output7_2 VGND output7_a_27_47# light_highway.2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output7_3 light_highway.2 output7_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output7_4 VPWR output7_a_27_47# light_highway.2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output7_5 output7_a_27_47# net7 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
